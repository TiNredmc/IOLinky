# Keil uVision project EVLIOL4LSV1.uvprojx, settings and files
target EVLIO4LSV1 (6210000::V6.21::ARMCLANG)
  device: STM32G071CBTx STMicroelectronics
  pack: Keil.STM32G0xx_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00009000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: EVLIOL4LSV1
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\src\src_drv;.\src\src_app;.\src\src_main;.\src\src_iol
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x9000
  group src_main
    ./src/src_main/: main.c main.h
  group src_app
    ./src/src_app/: app_device_impl.c app_device_impl.h gpio_pinout.h
  group src_drv
    ./src/src_drv/: clk.c clk.h Systick_delay.c Systick_delay.h spi.c spi.h
  group src_iol
    ./src/src_iol/: iol_pl.c iol_pl.h iol_l6364.c iol_l6364.h iol_dl.c iol_dl.h iol_al.c iol_al.h iol_sm.c iol_sm.h
software components: CMSIS:CORE 6.0.0, Device:Startup 1.4.2
