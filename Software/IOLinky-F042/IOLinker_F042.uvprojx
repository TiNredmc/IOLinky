# Keil uVision project IOLinker_F042.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F042F6Px STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00001800) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: IOLinker_F042 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c include: .\src\src_app;.\src\src_drv;.\src\src_iol;.\src\src_main
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1800
  group src_main
    ./src/src_main/: main.c main.h
  group src_iol
    ./src/src_iol/: iol_al.c iol_al.h iol_dl.c iol_dl.h iol_pl.c iol_pl.h iol_sm.c iol_sm.h iol_l6362.c iol_l6362.h
  group src_app
    ./src/src_app/: app_device_impl.c app_device_impl.h gpio_pinout.h
  group src_drv
    ./src/src_drv/: clk.c clk.h Systick_delay.c Systick_delay.h usart.c usart.h adc.c adc.h
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
