# Keil uVision project IOLinky_v1.0.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: GD32E230F8 GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.2
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: IOLinky_v1.0 +hex
  c flags: Optim=6 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: GD32E230
  c include: .\src\src_app;.\src\src_drv;.\src\src_iol;.\src\src_main
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group src_main
    ./src/src_main/: main.c main.h
  group src_drv
    ./src/src_drv/: adc.c adc.h clk.c clk.h Systick_delay.c Systick_delay.h usart.c usart.h
  group src_app
    ./src/src_app/: app_device_impl.c app_device_impl.h gpio_pinout.h
  group src_iol
    ./src/src_iol/: iol_al.c iol_al.h iol_dl.c iol_dl.h iol_l6362.c iol_l6362.h iol_pl.c iol_pl.h iol_sm.c iol_sm.h
software components: CMSIS:CORE 6.1.0, Device:GD32E23x_StdPeripherals:FMC 1.0.0, Device:GD32E23x_StdPeripherals:MISC 1.0.0, Device:GD32E23x_StdPeripherals:RCU 1.0.0, Device:GD32E23x_libopt 1.0.0, Device:Startup 1.0.0
